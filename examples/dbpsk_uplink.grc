options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dbpsk_uplink
    output_language: python
    title: DBPSK Uplink
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: frames_sent
  id: variable_function_probe
  parameters:
    block_id: ccsds_encoder
    function_name: num_frames
    poll_rate: '10'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: int(70e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: frames sent
    type: raw
    value: frames_sent
  states: {}
- name: ccsds_encoder
  id: ccsds_ccsds_encoder
  parameters:
    dual_basis: 'True'
    interleave: 'True'
    len_tag_key: '"packet_len"'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'True'
    scramble: 'True'
    type: message
    verbose: 'False'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ccsds_encoder, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [network_socket_pdu_0, pdus, ccsds_encoder, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
