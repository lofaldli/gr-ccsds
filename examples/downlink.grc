<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>downlink</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Downlink</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>antenna</value></param>
<param><key>value</key><value>RX2</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>RX2</value></param>
<param><key>option1</key><value>TX/RX</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>bandwidth_conf</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e3</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>max(1e6,samp_rate/2)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>bandwidth_conf</value></param>
<param><key>config_file</key><value>ccsds.conf</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>option</key><value>bandwidth</value></param>
<param><key>section</key><value>downlink</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>bandwidth</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_frames_decoded</value></param>
<param><key>poll_rate</key><value>fps</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_received</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_frames_received</value></param>
<param><key>poll_rate</key><value>fps</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>int(70e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sps*data_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>subframes_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_subframes_decoded</value></param>
<param><key>poll_rate</key><value>fps</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate,bandwidth,transwidth)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>transwidth</value></param>
<param><key>value</key><value>transwidth_conf</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e4</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>samp_rate/4</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>transwidth_conf</value></param>
<param><key>config_file</key><value>ccsds.conf</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>option</key><value>transwidth</value></param>
<param><key>section</key><value>downlink</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>transwidth</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>frames_received</value></param>
<param><key>gui_hint</key><value>qtgui@1:0,0</value></param>
<param><key>label</key><value>frames received</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0</value></param>
<param><key>value</key><value>frames_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@1:0,1</value></param>
<param><key>label</key><value>frames decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0_0</value></param>
<param><key>value</key><value>subframes_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@1:0,2</value></param>
<param><key>label</key><value>subframes decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>6e-2</value></param>
<param><key>decay_rate</key><value>1e-3</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>recording.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>samples.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/andre/recording_24_05_16_1015.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>1000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1e-3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>int(1e5)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ccsds_ccsds_decoder</key>
<param><key>id</key><value>ccsds_decoder</value></param>
<param><key>deinterleave</key><value>True</value></param>
<param><key>descramble</key><value>True</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_decode</key><value>True</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>bpsk</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label0</key><value>fft/const</value></param>
<param><key>label1</key><value>stats</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>qtgui@0:0,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/fps</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui@0:0,0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.25</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/fps</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>qtgui@1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>SNR</value></param>
<param><key>unit1</key><value>dB</value></param>
<param><key>label2</key><value>signal</value></param>
<param><key>unit2</key><value>dB</value></param>
<param><key>label3</key><value>noise</value></param>
<param><key>unit3</key><value>dB</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>update_time</key><value>1.0/fps</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>gui_hint</key><value>qtgui@1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>factor1</key><value>1.0*samp_rate/sps * 1.0/6.28</value></param>
<param><key>label1</key><value>doppler</value></param>
<param><key>unit1</key><value>Hz</value></param>
<param><key>max</key><value>0.5*samp_rate/sps</value></param>
<param><key>min</key><value>-0.5*samp_rate/sps</value></param>
<param><key>update_time</key><value>1.0/fps</value></param>
</block>
<block>
<key>snr_estimator</key>
<param><key>id</key><value>snr_estimator_0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>snr_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>ccsds_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>snr_estimator_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>snr_estimator_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>snr_estimator_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>snr_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
