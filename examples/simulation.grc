options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulation
    output_language: python
  states: {}

blocks:
- name: doppler
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1
    start: '-0.5*samp_rate/sps'
    step: 1e2
    stop: 0.5*samp_rate/sps
    value: '0.0'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: frames_decoded
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_frames_decoded
    poll_rate: '10'
    value: '0'
  states: {}
- name: frames_received
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_frames_received
    poll_rate: '10'
    value: '0'
  states: {}
- name: frames_sent
  id: variable_function_probe
  parameters:
    block_id: ccsds_encoder
    function_name: num_frames
    poll_rate: '10'
    value: '0'
  states: {}
- name: nframes
  id: variable
  parameters:
    value: int(1e4)
  states: {}
- name: noise_ampl
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,1
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: signal_ampl
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: subframes_decoded
  id: variable_function_probe
  parameters:
    block_id: ccsds_decoder
    function_name: num_subframes_decoded
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@2:0,0
    label: frames sent
    type: raw
    value: frames_sent
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@2:1,0
    label: frames received
    type: raw
    value: frames_received
  states: {}
- name: variable_qtgui_label_0_1_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@2:0,1
    label: frames decoded
    type: raw
    value: frames_decoded
  states: {}
- name: variable_qtgui_label_0_1_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tab@2:1,1
    label: subframes decoded
    type: raw
    value: subframes_decoded
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '6e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_ampl
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 1115*nframes
    type: byte
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: signal_ampl
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: 3.14 = samp_rate/2
    phase_inc: 6.28/samp_rate * doppler
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_lenn"'
    packet_len: '1115'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ccsds_decoder
  id: ccsds_ccsds_decoder
  parameters:
    deinterleave: 'True'
    descramble: 'True'
    dual_basis: 'True'
    n_deinterleave: '5'
    printing: 'False'
    rs_decode: 'True'
    threshold: '0'
    verbose: 'False'
  states: {}
- name: ccsds_encoder
  id: ccsds_ccsds_encoder
  parameters:
    dual_basis: 'True'
    interleave: 'True'
    len_tag_key: '"packet_lenn"'
    n_interleave: '5'
    printing: 'False'
    rs_encode: 'True'
    scramble: 'True'
    type: byte
    verbose: 'False'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: digital.constellation_bpsk().base()
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 6.28/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    gui_hint: tab@0:0,1
    legend: 'False'
    showports: 'True'
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    gui_hint: tab@0:0,0
    label1: signal
    label2: noise
    nconnections: '2'
    showports: 'True'
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    factor1: 1.0*samp_rate/sps * 1.0/6.28
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0
    label1: doppler
    max: 1e5
    min: '-1e5'
    type: float
    unit1: Hz
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,4
    label0: fft
    label1: const
    label2: stats
    num_tabs: '3'
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_0_0, '1']
- [analog_random_source_x_0, '0', blocks_head_0, '0']
- [blocks_add_xx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_head_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_rotator_cc_0, '0', analog_agc2_xx_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ccsds_encoder, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [ccsds_encoder, '0', digital_constellation_modulator_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '1', blocks_moving_average_xx_0, '0']
- [digital_diff_decoder_bb_0, '0', ccsds_decoder, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
